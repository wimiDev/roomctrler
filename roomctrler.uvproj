# Keil uVision project roomctrler.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: roomctrler +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./class/: 15io.h DELAY.c DELAY.h main.c NRF24L01.c NRF24L01.h uart.c uart.h global.h schduler.c schduler.h controller.c controller.h ds1302.h ds1302.c LCD5110.c LCD5110.h keyctrl.c keyctrl.h keyhandler.c keyhandler.h iddatabase.c iddatabase.h seting.c seting.h ligthcontroller.c ligthcontroller.h view.c view.h
